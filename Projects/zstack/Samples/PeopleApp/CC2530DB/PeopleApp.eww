<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\PeopleApp.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>PeopleApp</project>
        <configuration>CoordinatorEB</configuration>
      </member>
      <member>
        <project>PeopleApp</project>
        <configuration>RouterEB</configuration>
      </member>
      <member>
        <project>PeopleApp</project>
        <configuration>EndDeviceEB</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


