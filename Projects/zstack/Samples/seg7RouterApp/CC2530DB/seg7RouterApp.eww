<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\seg7RouterApp.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>seg7RouterApp</project>
        <configuration>CoordinatorEB</configuration>
      </member>
      <member>
        <project>seg7RouterApp</project>
        <configuration>RouterEB</configuration>
      </member>
      <member>
        <project>seg7RouterApp</project>
        <configuration>EndDeviceEB</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


